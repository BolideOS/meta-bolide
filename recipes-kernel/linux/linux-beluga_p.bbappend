FILESEXTRAPATHS:prepend := "${THISDIR}/linux-beluga:"

SRC_URI += "file://power-optimize.cfg"
