# Override AsteroidOS branding with BolideOS
DISTRO_NAME = "BolideOS"
DISTRO_VERSION = "0.9.1"
HOME_URL = "https://github.com/KonTy/bolideos"
